# Keil uVision project Project.uvprojx, settings and files
target ST25-Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ST25DVDemo
  AfterMake: $J\..\bin\fromelf.exe --bin --output=..\Binary\@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,USE_STM32F4XX_NUCLEO,USE_USB_FS,USE_ST25DV,USE_NFCTAG,USE_LCD,ST25DX_DISCOVERY_MB1283
  c misc: --C99 --reduce_paths
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\BSP\Components\stmpe811;..\..\..\..\..\Drivers\BSP\Components\ad5161\inc;..\..\..\..\..\Drivers\BSP\Components\ili9341_cube;..\..\..\..\..\Drivers\BSP\Components\ST25DV;..\..\..\..\..\Drivers\BSP\ST25-Discovery;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface;..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils;..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc;..\..\..\..\..\Middlewares\Third_Party\LibJPEG\include;..\..\..\..\..\Middlewares\ST\menu_demo;..\..\..\..\..\Middlewares\ST\lib_nfc\lib_NDEF\Core\inc;..\..\..\..\..\Middlewares\ST\lib_nfc\common\inc;..\Picture;..\..\..\..\..\Middlewares\ST\BlueNRG_Host_HID_Profile_1.1.0BETA\Projects\Bluetooth_LE\Profile_Framework\includes;..\..\..\..\..\Utilities\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f405xx.s
  group Example/User
    ../Src/: bluenrg_interface.c commonfunc.c flash_if.c fs_api.c fw_command.c hid_application.c jdata_conf.c jpeg_decode.c lib_NDEF_config.c mailbox.c mailboxfunc.c main.c Menu_config.c Menu_definition.c ndef_demo.c scope.c st25dv_features_demo.c stm32f4xx_hal_msp.c stm32f4xx_it.c usbd_conf.c usbd_desc.c usbd_storage.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/ad5161/src/: ad5161_Cube.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../Drivers/BSP/Components/ili9341_cube/: ili9341_cube.c
    ../../../../../Drivers/BSP/Components/ST25DV/: st25dv.c st25dv_reg.c
  group Drivers/BSP/ST25-Discovery
    ../../../../../Drivers/BSP/ST25-Discovery/: st25dx_bluenrg_ble.c st25dx_discovery.c st25dx_discovery_bus.c st25dx_discovery_dpot.c st25dx_discovery_lcd.c st25dx_discovery_nfctag.c st25dx_discovery_ts.c st25dx_spwf_wifi.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/STM32_USB_Device_Library
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_BlueNRG/HCI
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/STM32_BlueNRG/Utils
    ../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c osal.c ble_list.c
  group Middlewares/STM32_SPWF01SA
    ../../../../../Middlewares/ST/STM32_SPWF01SA/: wifi_interface.c wifi_module.c
    ../../../../../Middlewares/ST/STM32_SPWF01SA/Utils/: event_buffer.c ring_buffer.c
  group Middlewares/Lib_NDEF
    ../../../../../Middlewares/ST/lib_nfc/lib_NDEF/Core/src/: lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Bluetooth.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_Handover.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_Text.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Wifi.c lib_wrapper.c tagtype5_wrapper.c tagtype3_wrapper.c tagtype4_wrapper.c
  group Middlewares/Jpeg
    ../../../../../Middlewares/Third_Party/LibJPEG/source/: jcmarker.c jcmaster.c jdcolor.c jdmaster.c jdsample.c jfdctfst.c jutils.c jccoefct.c jcsample.c jdapimin.c jidctfst.c jquant1.c jquant2.c jcinit.c jdapistd.c jctrans.c jdpostct.c jcapistd.c jcparam.c jerror.c jfdctint.c jcdctmgr.c jdmerge.c jddctmgr.c jidctint.c jdcoefct.c jdinput.c jcapimin.c jcarith.c jaricom.c jdmainct.c jidctflt.c jdarith.c jdhuff.c jcmainct.c jdatasrc.c jcprepct.c jdtrans.c jmemnobs.c jdatadst.c jchuff.c jdmarker.c jmemmgr.c jcomapi.c jfdctflt.c jccolor.c
  group Middlewares/Menu_Demo
    ../../../../../Middlewares/ST/menu_demo/: Menu_core.c
  group Middleware/BlueNRG_Host_HID_Profile
    ../../../../../Middlewares/ST/BlueNRG_Host_HID_Profile_1.1.0BETA/Projects/Bluetooth_LE/Profile_Framework/profiles/hid_device/: hid_device.c hid_device_sm_services.c
    ../../../../../Middlewares/ST/BlueNRG_Host_HID_Profile_1.1.0BETA/Projects/Bluetooth_LE/Profile_Framework/utils/: timer.c
    ../../../../../Middlewares/ST/BlueNRG_Host_HID_Profile_1.1.0BETA/Projects/Bluetooth_LE/Profile_Framework/profiles/ble_profile/: profile.c
