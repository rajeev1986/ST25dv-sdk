# Keil uVision project Project.uvprojx, settings and files
target ST25-Discovery_FwUpgrd (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ST25DVDemo_FwUpgrd
  AfterMake: $J\..\bin\fromelf.exe --bin --output=..\Binary\@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,USE_STM32F4XX_NUCLEO,USE_ST25DV,USE_NFCTAG,USE_LCD
  c misc: --C99 --gnu --reduce_paths
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\BSP\Components\stmpe811;..\..\..\..\..\Drivers\BSP\Components\ad5161\inc;..\..\..\..\..\Drivers\BSP\Components\ili9341_cube;..\..\..\..\..\Drivers\BSP\Components\ST25DV;..\..\..\..\..\Drivers\BSP\ST25-Discovery;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface;..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils;..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc;..\..\..\..\..\Middlewares\Third_Party\LibJPEG\include;..\..\..\..\..\Middlewares\ST\menu_demo;..\..\..\..\..\Middlewares\ST\lib_nfc\lib_NDEF\inc;..\..\..\..\..\Middlewares\ST\lib_nfc\common\inc;..\Picture;..\..\..\..\..\Utilities\Fonts
  library: MicroLIB
  memory RVCT4: ROM 0x80a0000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f405xx.s
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c MenuDefinition.c Menu_config.c fs_api.c jpeg_decode.c flash_if.c commonfunc.c st25dv_features_demo.c fw_command.c jdata_conf.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../Drivers/BSP/Components/ad5161/src/: ad5161_Cube.c
    ../../../../../Drivers/BSP/Components/ili9341_cube/: ili9341_cube.c
    ../../../../../Drivers/BSP/Components/ST25DV/: st25dv.c st25dv_reg.c
  group Drivers/BSP/ST25-Discovery
    ../../../../../Drivers/BSP/ST25-Discovery/: st25dx_discovery.c st25dx_discovery_dpot.c st25dx_discovery_lcd.c st25dx_discovery_nfctag.c st25dx_discovery_ts.c st25dx_discovery_bus.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/Jpeg
    ../../../../../Middlewares/Third_Party/LibJPEG/source/: jcmarker.c jcmaster.c jdcolor.c jdmaster.c jdsample.c jfdctfst.c jutils.c jccoefct.c jcsample.c jdapimin.c jidctfst.c jquant1.c jquant2.c jcinit.c jdapistd.c jctrans.c jdpostct.c jcapistd.c jcparam.c jerror.c jfdctint.c jcdctmgr.c jdmerge.c jddctmgr.c jidctint.c jdcoefct.c jdinput.c jcapimin.c jcarith.c jaricom.c jdmainct.c jidctflt.c jdarith.c jdhuff.c jcmainct.c jdatasrc.c jcprepct.c jdtrans.c jmemnobs.c jdatadst.c jchuff.c jdmarker.c jmemmgr.c jcomapi.c jfdctflt.c jccolor.c
  group Middlewares/Menu_Demo
    ../../../../../Middlewares/ST/menu_demo/: Menu_core.c
